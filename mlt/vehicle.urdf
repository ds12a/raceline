Commit message: playing with pinocchio + params

File: mlt/vehicle.urdf (robot description, URDF)
Before this commit: robot vehicle, 6 links, 5 joints
Links:
- link b1: mass None -> 0.001
- link b2: mass None -> 0.001
- link b4: mass None -> 0.001
- link b5: mass None -> 0.001
